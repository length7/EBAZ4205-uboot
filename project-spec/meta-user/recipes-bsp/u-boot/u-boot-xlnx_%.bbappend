FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://platform-top.h \
            file://user_2024-11-11-09-14-00.cfg \
            file://user_2024-11-11-09-17-00.cfg \
            file://user_2024-11-11-09-25-00.cfg \
            file://user_2024-11-11-09-52-00.cfg \
            file://user_2024-11-28-14-43-00.cfg \
            file://user_2024-11-28-15-48-00.cfg \
            "
