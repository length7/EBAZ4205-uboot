SRC_URI += "file://user_2024-11-11-15-35-00.cfg \
            file://user_2024-11-12-12-59-00.cfg \
            file://user_2024-11-12-13-13-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

